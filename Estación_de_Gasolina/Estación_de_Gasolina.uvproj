# Keil uVision project Estación_de_Gasolina.uvproj, settings and files
target Estación_de_Gasolina (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: Estación_de_Gasolina
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: startup.s tm4c123gh6pm.h main.c UART.c UART.h PLL.c PLL.h ST7735.c ST7735.h
